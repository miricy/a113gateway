## buildroot/package/yk_gateway/Config.in
```kconfig
config BR2_PACKAGE_YK_GATEWAY
	bool "yekert smartHome gateWay"
	help
	  SmartHome gateWay package
```
